# Keil uVision project STM32F407_Cube_Driver.uvprojx, settings and files
target STM32F407_Cube_Driver (ARM-ADS)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F407_Cube_Driver
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_spi.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c
  group Application/User
    ../Src/: main.c stm32f4xx_it.c adc.c i2c.c usart.c spi.c tim.c can.c gpio.c stm32f4xx_hal_msp.c freertos.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: queue.c list.c event_groups.c croutine.c timers.c tasks.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
software components: CMSIS:CORE 4.1.0
